# IAR project PDMA_ScatterGather_PingPongBuffer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC126AE series Nuvoton NUC126AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC126\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PDMA_ScatterGather_PingPongBuffer.bin
  ILINK.IlinkOutputFile: PDMA_ScatterGather_PingPongBuffer.out
  ILINK.IlinkIcfFile: PDMA_ScatterGather_PingPongBuffer.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/IAR/: startup_NUC126.s
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
