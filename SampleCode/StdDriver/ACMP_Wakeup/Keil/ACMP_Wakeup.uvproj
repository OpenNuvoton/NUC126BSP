# Keil uVision project ACMP_Wakeup.uvproj, settings and files
target ACMP_Wakeup (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ACMP_Wakeup
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC126.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
    ../../../../Library/Device/Nuvoton/NUC126/Source/ARM/: startup_NUC126.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c acmp.c clk.c
