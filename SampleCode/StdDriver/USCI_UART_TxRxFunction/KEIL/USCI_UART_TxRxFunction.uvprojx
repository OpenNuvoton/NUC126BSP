# Keil uVision project USCI_UART_TxRxFunction.uvprojx, settings and files
target USCI_UART_TxRxFunction (6160000::V6.16::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USCI_UART_TxRxFunction
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=3
  c define: DEBUG_PORT=UUART0
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC126.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/ARM/: startup_NUC126.s
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c usci_uart.c
    ../: myretarget.c
