# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC126_ISP_UART0_PD0_PD1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC126.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/ARM/: startup_NUC126.s
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c uart_transfer.c
