# Keil uVision project FMC_IAP.uvprojx, settings and files
target FMC_IAP_LD (6190000::V6.19::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_IAP_LD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC126.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
    ../../../../Library/Device/Nuvoton/NUC126/Source/ARM/: startup_NUC126.s
  group User
    ../: main.c LoaderImage.s main_LD.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
target FMC_IAP (6160000::V6.16::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: as above
  output: FMC_IAP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
