# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_MultiBoot (6220000::V6.22::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __BASE__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC126.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
    ../../../../Library/Device/Nuvoton/NUC126/Source/ARM/: startup_NUC126.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
target FMC_Boot0 (6160000::V6.16::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: as above
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __BOOT0__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
target FMC_Boot1 (6160000::V6.16::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __BOOT1__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
target FMC_Boot2 (6160000::V6.16::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: as above
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __BOOT2__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
target FMC_Boot3 (6220000::V6.22::ARMCLANG)
  device: NUC126VG4AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.0
  cpu: as above
  output: FMC_Boot3
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __BOOT3__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
