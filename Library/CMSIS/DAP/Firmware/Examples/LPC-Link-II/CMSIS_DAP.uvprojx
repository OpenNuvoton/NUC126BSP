# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target LPC4320 SPIFI (ARM-ADS)
  device: LPC4320:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.4.0
  cpu: IRAM(0x10000000,0x18000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DAP
  c flags: Optim=4 wLevel=2
  c include: .;..\..\Include
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c USBD_User_HID_0.c
  group Documentation
    ./: Abstract.txt
  group CMSIS DAP
    ../../Source/: DAP.c JTAG_DP.c SW_DP.c SWO.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, USB:CORE 6.4.0, USB:Device 6.4.0, USB:Device:HID 6.4.0, CMSIS Driver:USART 2.07, CMSIS Driver:USB Device:USB0 2.07, Device:GPDMA 1.03, Device:SCU 1.00, Device:Startup 1.0.0
